.title KiCad schematic
V1 /multiplexer-4-4-1/Vcc 0 dc 5
V2 /A1in 0 dc 5
V3 /A2in 0 dc 5
V4 /A3in 0 dc 5
V5 /A4in 0 dc 5
V9 /B4in 0 dc 5
V8 /B3in 0 dc 5
V7 /B2in 0 dc 5
V6 /B1in 0 dc 5
V18 /S1in 0 dc 5
V13 /C4in 0 dc 5
V12 /C3in 0 dc 5
V11 /C2in 0 dc 5
V10 /C1in 0 dc 5
V17 /D4in 0 dc 5
V16 /D3in 0 dc 5
V15 /D2in 0 dc 5
V14 /D1in 0 dc 5
V19 /S2in 0 dc 5
R2 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A1 1K
R1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 10K
Q1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 0 NPN
R5 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q 1K
R3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
R4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
Q2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R8 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A 1K
R6 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R7 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R10 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A 1K
R9 /A1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R12 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B 1K
R11 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 10K
Q5 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R15 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B 1K
R13 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R14 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q6 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R17 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A 1K
R16 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q7 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R19 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B 1K
R18 /B1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 10K
Q8 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R21 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B 1K
R20 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 10K
Q9 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 0 NPN
R23 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A2 1K
R22 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 10K
Q10 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 0 NPN
R26 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q 1K
R24 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
R25 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
Q11 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R29 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A 1K
R27 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R28 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q12 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R31 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A 1K
R30 /A2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q13 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R33 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B 1K
R32 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 10K
Q14 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R36 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B 1K
R34 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R35 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q15 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R38 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A 1K
R37 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q16 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R40 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B 1K
R39 /B2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 10K
Q17 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R42 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B 1K
R41 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 10K
Q18 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 0 NPN
R44 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A3 1K
R43 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 10K
Q19 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 0 NPN
R47 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q 1K
R45 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
R46 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
Q20 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R50 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A 1K
R48 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R49 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q21 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R52 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A 1K
R51 /A3in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q22 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R54 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B 1K
R53 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 10K
Q23 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R57 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B 1K
R55 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R56 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q24 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R59 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A 1K
R58 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q25 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R61 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B 1K
R60 /B3in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 10K
Q26 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R63 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B 1K
R62 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 10K
Q27 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 0 NPN
R65 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A4 1K
R64 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 10K
Q28 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 0 NPN
R68 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q 1K
R66 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
R67 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
Q29 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R71 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A 1K
R69 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R70 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q30 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R73 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A 1K
R72 /A4in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q31 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R75 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B 1K
R74 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 10K
Q32 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R78 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B 1K
R76 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R77 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q33 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R80 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A 1K
R79 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q34 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R82 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B 1K
R81 /B4in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 10K
Q35 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R84 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B 1K
R83 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 10K
Q36 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-1/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 0 NPN
R86 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B1 1K
R85 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 10K
Q37 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 0 NPN
R89 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q 1K
R87 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
R88 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
Q38 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R92 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A 1K
R90 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R91 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q39 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R94 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A 1K
R93 /C1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q40 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R96 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B 1K
R95 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 10K
Q41 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R99 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B 1K
R97 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R98 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q42 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R101 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A 1K
R100 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q43 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R103 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B 1K
R102 /D1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 10K
Q44 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R105 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B 1K
R104 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 10K
Q45 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 0 NPN
R107 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B2 1K
R106 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 10K
Q46 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 0 NPN
R110 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q 1K
R108 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
R109 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
Q47 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R113 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A 1K
R111 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R112 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q48 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R115 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A 1K
R114 /C2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q49 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R117 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B 1K
R116 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 10K
Q50 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R120 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B 1K
R118 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R119 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q51 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R122 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A 1K
R121 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q52 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R124 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B 1K
R123 /D2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 10K
Q53 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R126 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B 1K
R125 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 10K
Q54 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 0 NPN
R128 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B3 1K
R127 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 10K
Q55 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 0 NPN
R131 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q 1K
R129 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
R130 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
Q56 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R134 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A 1K
R132 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R133 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q57 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R136 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A 1K
R135 /C3in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q58 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R138 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B 1K
R137 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 10K
Q59 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R141 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B 1K
R139 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R140 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q60 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R143 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A 1K
R142 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q61 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R145 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B 1K
R144 /D3in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 10K
Q62 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R147 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B 1K
R146 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 10K
Q63 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 0 NPN
R149 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B4 1K
R148 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 10K
Q64 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 0 NPN
R152 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q 1K
R150 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
R151 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
Q65 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R155 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A 1K
R153 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R154 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q66 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R157 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A 1K
R156 /C4in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q67 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R159 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B 1K
R158 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 10K
Q68 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R162 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B 1K
R160 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R161 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q69 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R164 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A 1K
R163 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q70 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R166 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B 1K
R165 /D4in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 10K
Q71 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R168 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B 1K
R167 /S1in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 10K
Q72 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-2/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 0 NPN
R170 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/Z1 1K
R169 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 10K
Q73 /multiplexer-4-4-1/Z1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-not-1/Qr 0 NPN
R173 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q 1K
R171 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
R172 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 10K
Q74 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R176 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A 1K
R174 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R175 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q75 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R178 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A 1K
R177 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q76 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R180 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B 1K
R179 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 10K
Q77 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R183 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B 1K
R181 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R182 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q78 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R185 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A 1K
R184 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q79 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R187 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B 1K
R186 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B1 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 10K
Q80 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R189 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B 1K
R188 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 10K
Q81 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-1/mux-2-1-not-1/Qr 0 NPN
R191 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/Z2 1K
R190 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 10K
Q82 /multiplexer-4-4-1/Z2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-not-1/Qr 0 NPN
R194 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q 1K
R192 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
R193 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 10K
Q83 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R197 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A 1K
R195 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R196 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q84 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R199 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A 1K
R198 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q85 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R201 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B 1K
R200 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 10K
Q86 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R204 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B 1K
R202 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R203 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q87 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R206 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A 1K
R205 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q88 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R208 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B 1K
R207 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B2 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 10K
Q89 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R210 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B 1K
R209 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 10K
Q90 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-2/mux-2-1-not-1/Qr 0 NPN
R212 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/Z3 1K
R211 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 10K
Q91 /multiplexer-4-4-1/Z3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-not-1/Qr 0 NPN
R215 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q 1K
R213 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
R214 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 10K
Q92 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R218 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A 1K
R216 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R217 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q93 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R220 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A 1K
R219 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q94 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R222 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B 1K
R221 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 10K
Q95 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R225 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B 1K
R223 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R224 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q96 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R227 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A 1K
R226 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q97 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R229 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B 1K
R228 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B3 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 10K
Q98 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R231 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B 1K
R230 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 10K
Q99 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-3/mux-2-1-not-1/Qr 0 NPN
R233 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/Z4 1K
R232 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 10K
Q100 /multiplexer-4-4-1/Z4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-not-1/Qr 0 NPN
R236 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q 1K
R234 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
R235 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 10K
Q101 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/Q /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R239 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A 1K
R237 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R238 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q102 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R241 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A 1K
R240 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/A4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q103 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R243 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B 1K
R242 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 10K
Q104 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R246 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B 1K
R244 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R245 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q105 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-or-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R248 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A 1K
R247 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q106 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R250 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B 1K
R249 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/B4 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 10K
Q107 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R252 /multiplexer-4-4-1/Vcc /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B 1K
R251 /S2in /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 10K
Q108 /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-and-1/B /multiplexer-4-4-1/multiplexer-4-4-1-mux-4-2-1-3/multiplexer-4-2-1-mux-1-2-1-4/mux-2-1-not-1/Qr 0 NPN
.end
