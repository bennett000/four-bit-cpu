.title KiCad schematic
V1 /adder-1/Vcc 0 dc 5
V2 /Ain 0 dc 5
V3 /Bin 0 dc 5
V4 /Cin 0 dc 5
R3 /adder-1/Vcc /adder-1/sheet5C34B00D/A 1K
R1 /Ain /adder-1/sheet5C34AF27/AorB 10K
R2 /Bin /adder-1/sheet5C34AF27/AorB 10K
Q1 /adder-1/sheet5C34B00D/A /adder-1/sheet5C34AF27/AorB 0 NPN
R6 /adder-1/Vcc /adder-1/sheet5C34B027/A 1K
R4 /Ain /adder-1/sheet5C34AFF9/AorB 10K
R5 /adder-1/sheet5C34B00D/A /adder-1/sheet5C34AFF9/AorB 10K
Q2 /adder-1/sheet5C34B027/A /adder-1/sheet5C34AFF9/AorB 0 NPN
R9 /adder-1/Vcc /adder-1/sheet5C34B027/B 1K
R7 /adder-1/sheet5C34B00D/A /adder-1/sheet5C34B00D/AorB 10K
R8 /Bin /adder-1/sheet5C34B00D/AorB 10K
Q3 /adder-1/sheet5C34B027/B /adder-1/sheet5C34B00D/AorB 0 NPN
R12 /adder-1/Vcc /adder-1/sheet5C34B047/A 1K
R10 /adder-1/sheet5C34B027/A /adder-1/sheet5C34B027/AorB 10K
R11 /adder-1/sheet5C34B027/B /adder-1/sheet5C34B027/AorB 10K
Q4 /adder-1/sheet5C34B047/A /adder-1/sheet5C34B027/AorB 0 NPN
R15 /adder-1/Vcc /adder-1/sheet5C34B049/A 1K
R13 /adder-1/sheet5C34B047/A /adder-1/sheet5C34B047/AorB 10K
R14 /Cin /adder-1/sheet5C34B047/AorB 10K
Q5 /adder-1/sheet5C34B049/A /adder-1/sheet5C34B047/AorB 0 NPN
R18 /adder-1/Vcc /adder-1/sheet5C34B04A/A 1K
R16 /adder-1/sheet5C34B047/A /adder-1/sheet5C34B048/AorB 10K
R17 /adder-1/sheet5C34B049/A /adder-1/sheet5C34B048/AorB 10K
Q6 /adder-1/sheet5C34B04A/A /adder-1/sheet5C34B048/AorB 0 NPN
R21 /adder-1/Vcc /adder-1/sheet5C34B04A/B 1K
R19 /adder-1/sheet5C34B049/A /adder-1/sheet5C34B049/AorB 10K
R20 /Cin /adder-1/sheet5C34B049/AorB 10K
Q7 /adder-1/sheet5C34B04A/B /adder-1/sheet5C34B049/AorB 0 NPN
R24 /adder-1/Vcc /S 1K
R22 /adder-1/sheet5C34B04A/A /adder-1/sheet5C34B04A/AorB 10K
R23 /adder-1/sheet5C34B04A/B /adder-1/sheet5C34B04A/AorB 10K
Q8 /S /adder-1/sheet5C34B04A/AorB 0 NPN
R27 /adder-1/Vcc /adder-1/Cout 1K
R25 /adder-1/sheet5C34B049/A /adder-1/sheet5C34B0CD/AorB 10K
R26 /adder-1/sheet5C34B00D/A /adder-1/sheet5C34B0CD/AorB 10K
Q9 /adder-1/Cout /adder-1/sheet5C34B0CD/AorB 0 NPN
.end
