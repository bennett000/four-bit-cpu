.title KiCad schematic
V1 /multiplexer-1-2-1/Vcc 0 dc 5
V2 /Ain 0 dc 5
V3 /Bin 0 dc 5
V4 /SelIn 0 dc 5
R2 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/Z 1K
R1 /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-1-2-1/mux-2-1-or-1/or-not-1/Qr 10K
Q1 /multiplexer-1-2-1/Z /multiplexer-1-2-1/mux-2-1-or-1/or-not-1/Qr 0 NPN
R5 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/Q 1K
R3 /multiplexer-1-2-1/mux-2-1-or-1/A /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/AorB 10K
R4 /multiplexer-1-2-1/mux-2-1-or-1/B /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/AorB 10K
Q2 /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/Q /multiplexer-1-2-1/mux-2-1-or-1/or-nor-1/AorB 0 NPN
R8 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-or-1/A 1K
R6 /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
R7 /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/AorB 10K
Q3 /multiplexer-1-2-1/mux-2-1-or-1/A /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/AorB 0 NPN
R10 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/A 1K
R9 /Ain /multiplexer-1-2-1/mux-2-1-and-1/Sheet5C3654CC/Qr 10K
Q4 /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/A /multiplexer-1-2-1/mux-2-1-and-1/Sheet5C3654CC/Qr 0 NPN
R12 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/B 1K
R11 /multiplexer-1-2-1/mux-2-1-and-1/B /multiplexer-1-2-1/mux-2-1-and-1/sheet5C366192/Qr 10K
Q5 /multiplexer-1-2-1/mux-2-1-and-1/sheet5C364DB7/B /multiplexer-1-2-1/mux-2-1-and-1/sheet5C366192/Qr 0 NPN
R15 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-or-1/B 1K
R13 /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
R14 /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/AorB 10K
Q6 /multiplexer-1-2-1/mux-2-1-or-1/B /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/AorB 0 NPN
R17 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/A 1K
R16 /SelIn /multiplexer-1-2-1/mux-2-1-and-2/Sheet5C3654CC/Qr 10K
Q7 /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/A /multiplexer-1-2-1/mux-2-1-and-2/Sheet5C3654CC/Qr 0 NPN
R19 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/B 1K
R18 /Bin /multiplexer-1-2-1/mux-2-1-and-2/sheet5C366192/Qr 10K
Q8 /multiplexer-1-2-1/mux-2-1-and-2/sheet5C364DB7/B /multiplexer-1-2-1/mux-2-1-and-2/sheet5C366192/Qr 0 NPN
R21 /multiplexer-1-2-1/Vcc /multiplexer-1-2-1/mux-2-1-and-1/B 1K
R20 /SelIn /multiplexer-1-2-1/mux-2-1-not-1/Qr 10K
Q9 /multiplexer-1-2-1/mux-2-1-and-1/B /multiplexer-1-2-1/mux-2-1-not-1/Qr 0 NPN
.end
