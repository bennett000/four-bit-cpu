.title KiCad schematic
V1 /flip-flop-d/Vcc 0 dc 5
V2 /Din 0 dc 5
V3 /ClkIn 0 dc 5
R3 /flip-flop-d/Vcc /flip-flop-d/sr-latch-d/Q 1K
R1 /flip-flop-d/flip-flop-d-nor-3/A /flip-flop-d/sr-latch-d/latch-sr-nor-1/AorB 10K
R2 /flip-flop-d/sr-latch-d/NQ /flip-flop-d/sr-latch-d/latch-sr-nor-1/AorB 10K
Q1 /flip-flop-d/sr-latch-d/Q /flip-flop-d/sr-latch-d/latch-sr-nor-1/AorB 0 NPN
R6 /flip-flop-d/Vcc /flip-flop-d/sr-latch-d/NQ 1K
R4 /flip-flop-d/sr-latch-d/Q /flip-flop-d/sr-latch-d/latch-sr-nor-2/AorB 10K
R5 /flip-flop-d/flip-flop-d-nor-4/A /flip-flop-d/sr-latch-d/latch-sr-nor-2/AorB 10K
Q2 /flip-flop-d/sr-latch-d/NQ /flip-flop-d/sr-latch-d/latch-sr-nor-2/AorB 0 NPN
R9 /flip-flop-d/Vcc /flip-flop-d/flip-flop-d-nor-2/A 1K
R7 /flip-flop-d/flip-flop-d-nor-1/A /flip-flop-d/flip-flop-d-nor-1/AorB 10K
R8 /flip-flop-d/flip-flop-d-nor-3/A /flip-flop-d/flip-flop-d-nor-1/AorB 10K
Q3 /flip-flop-d/flip-flop-d-nor-2/A /flip-flop-d/flip-flop-d-nor-1/AorB 0 NPN
R12 /flip-flop-d/Vcc /flip-flop-d/flip-flop-d-nor-3/A 1K
R10 /flip-flop-d/flip-flop-d-nor-2/A /flip-flop-d/flip-flop-d-nor-2/AorB 10K
R11 /ClkIn /flip-flop-d/flip-flop-d-nor-2/AorB 10K
Q4 /flip-flop-d/flip-flop-d-nor-3/A /flip-flop-d/flip-flop-d-nor-2/AorB 0 NPN
R16 /flip-flop-d/Vcc /flip-flop-d/flip-flop-d-nor-4/A 1K
R13 /flip-flop-d/flip-flop-d-nor-3/A /flip-flop-d/flip-flop-d-nor-3/AorBorC 10K
R14 /ClkIn /flip-flop-d/flip-flop-d-nor-3/AorBorC 10K
Q5 /flip-flop-d/flip-flop-d-nor-4/A /flip-flop-d/flip-flop-d-nor-3/AorBorC 0 NPN
R15 /flip-flop-d/flip-flop-d-nor-1/A /flip-flop-d/flip-flop-d-nor-3/AorBorC 10K
R19 /flip-flop-d/Vcc /flip-flop-d/flip-flop-d-nor-1/A 1K
R17 /flip-flop-d/flip-flop-d-nor-4/A /flip-flop-d/flip-flop-d-nor-4/AorB 10K
R18 /Din /flip-flop-d/flip-flop-d-nor-4/AorB 10K
Q6 /flip-flop-d/flip-flop-d-nor-1/A /flip-flop-d/flip-flop-d-nor-4/AorB 0 NPN
.end
